# Keil uVision project curtain.uvproj, settings and files
target Curtain (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: curtain +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\user\include
  group Source Group 1
    ./: STARTUP.A51
  group User
    ../user/: delay.c esp8266.c lux.c main.c
